# Keil uVision project AudioPlayer.uvproj, settings and files
target AudioPlayer (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: AudioPlayer +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\SRAM;..\HARDWARE\SDIO;..\MALLOC;..\USMART;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\FWLIB\inc;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\I2S;..\HARDWARE\WM8978;..\APP;..\AUDIOCODEC\wav;..\HARDWARE\OLED;..\AUDIOCODEC\ape\apedec;..\AUDIOCODEC\flac\flacdec;..\AUDIOCODEC\mp3\helix;..\AUDIOCODEC\ape;..\AUDIOCODEC\flac;..\AUDIOCODEC\mp3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/I2S/: i2s.c
    ../HARDWARE/WM8978/: wm8978.c
    ../HARDWARE/OLED/: oled.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_dma.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group AUDIOCODEC_WAV
    ../AUDIOCODEC/wav/: wavplay.c
  group APP
    ../APP/: audioplay.c
  group AUDIOCODEC_MP3
    ../AUDIOCODEC/mp3/: mp3play.c
    ../AUDIOCODEC/mp3/helix/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs.c
    ../AUDIOCODEC/mp3/helix/arm/: asmmisc_rvds.s asmpoly_thumb2_rvds.s
  group AUDIOCODEC_FLAC
    ../AUDIOCODEC/flac/: flacplay.c
    ../AUDIOCODEC/flac/flacdec/: bitstreamf.c flacdecoder.c tables.c
